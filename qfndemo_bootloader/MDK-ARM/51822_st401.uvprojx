# Keil uVision project 51822_st401.uvprojx, settings and files
target 51822_st401 (ARM-ADS)
  device: STM32F401CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x08000000-0x0807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: 51822_st401
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE
  c misc: --C99
  c include: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: usart.c stm32f4xx_hal_msp.c stm32f4xx_it.c main.c gpio.c comm.c
  group Application/MDK-ARM
    ./: startup_stm32f401xe.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash.c stm32f4xx_hal_tim.c stm32f4xx_hal_rtc.c stm32f4xx_hal.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_cortex.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
software components: CMSIS:CORE 4.1.0
